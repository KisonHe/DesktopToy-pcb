# Repository KisonHe/DesktopToy-pcb

## KiCad design DesktopToy/DesktopToy.kicad_pcb

Parts:
C1, C5: 100nf; C_0603_1608Metric
C2: 10uf; C_0805_2012Metric
C3, C6, C7, C8, C9, C10, C11: 1uf; C_0603_1608Metric
C4: 0.1uF; C_0603_1608Metric; LCSC C1591
C12: 0.1uF; C_0402_1005Metric; LCSC C1591
D1: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
D2: D; D_SOD-323; LCSC C191023
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J2: ESPProgUART_RX; IDC_1.27mm_6P
J3: Conn_01x18; Hirose_FH12-18S-0.5SH_1x18-1MP_P0.50mm_Horizontal
JP1: Jumper; R_0603_1608Metric
Q1: MMBT3904; SOT-23
Q2: 2N7002; SOT-23; Digikey 2N7002H6327XTSA2CT-ND
R1: 100k; R_0603_1608Metric; LCSC C429617
R2, R8, R9: 0; R_0603_1608Metric
R3: 10k; R_0603_1608Metric
R4, R5: 5.1k; R_0603_1608Metric
R6, R7: 3.3k; R_0603_1608Metric
R10: 1.5k; R_0402_1005Metric; LCSC C429617
R11: 10k; R_0402_1005Metric; LCSC C429617
R12: 10k; R_0603_1608Metric; Digikey RMCF0603JT10K0CT-ND
R13: 1M; R_0603_1608Metric; Digikey RMCF0603JT1M00CT-ND
TP1: TestPoint; TestPoint_Pad_1.5x1.5mm
TP2, TP3: TestPoint; TestPoint_Pad_2.0x2.0mm
U1: KT148A; SOP-8_3.9x4.9mm_P1.27mm
U2: ESP32-S3-WROOM-1
U3: LIS2DH12TR; PQFN50P200X200100-12N
U4: USBLC6-2SC6; SOT-23-6
U5: VEML7700; Digikey VEML7700-TT
U6, U7: XC6209; SOT-23-5
U8: LP5907MFX-1.8; SOT-23-5

Connections:
+1V8: C11.1, J3.15, U8.5 (OUT)
+3V0: C9.1, J3.2, J3.16, U7.5 (VOUT)
+5V: C6.1, C7.1, C10.2, C12.1, D1.1 (VDD), D2.1 (K), R11.2, U6.1 (VIN), U6.3 (CE), U7.1 (VIN), U7.3 (CE), U8.1 (IN), U8.3 (EN)
/BLK: R12.1, U2.19 (GPIO11/TOUCH11/ADC2_CH0/FSPID/FSPIIO5/S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)
/BOOT: J2.6 (IO0), TP1.1, U2.27 (GPIO0/BOOT)
/D+: J1.A6 (D+), J1.B6 (D+), U2.14 (GPIO20/U1CTS/ADC2_CH9/CLK_OUT1/USB_D+), U4.1 (I/O1), U4.6 (I/O1)
/D-: J1.A7 (D-), J1.B7 (D-), U2.13 (GPIO19/U1RTS/ADC2_CH8/CLK_OUT2/USB_D-), U4.3 (I/O2), U4.4 (I/O2)
/EN: C3.1, J2.1 (EN), R3.2, U2.3 (EN)
/I2C_SCL: J3.6, R6.2, U2.7 (GPIO7/TOUCH7/ADC1_CH6), U3.1 (SCL/SPC), U5.1 (SCL)
/I2C_SDA: J3.5, R7.2, U2.6 (GPIO6/TOUCH6/ADC1_CH5), U3.4 (SDA/SDI/SDO), U5.4 (SDA)
/KT148A_Busy: U1.2 (Busy/TX), U2.17 (GPIO9/TOUCH9/ADC1_CH8/FSPIHD/SUBSPIHD)
/KT148A_Data: U1.3 (DATA/RX), U2.18 (GPIO10/TOUCH10/ADC1_CH9/FSPICS0/FSPIIO4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)
/LCD_CLK: J3.10, U2.10 (GPIO17/U1TXD/ADC2_CH6)
/LCD_CS: J3.11, U2.11 (GPIO18/U1RXD/ADC2_CH7/CLK_OUT3)
/LCD_DC: J3.12, U2.12 (GPIO8/TOUCH8/ADC1_CH7/SUBSPICS1)
/LCD_RESET: J3.8, U2.8 (GPIO15/U0RTS/ADC2_CH4/XTAL_32K_P)
/LCD_SDA: J3.9, U2.9 (GPIO16/U0CTS/ADC2_CH5/XTAL_32K_NH5)
/LEDK: J3.17, Q2.3 (D)
/RGB_Data: Q1.2 (E), U2.15 (GPIO3/TOUCH3/ADC1_CH2)
/TOUCH_TINT: J3.3, U2.5 (GPIO5/TOUCH5/ADC1_CH4)
/TOUCH_TRST: J3.4, U2.4 (GPIO4/TOUCH4/ADC1_CH3)
/U0RX: R9.2, U2.36 (U0RXD/GPIO44/CLK_OUT2)
/U0TX: R8.1, U2.37 (U0TXD/GPIO43/CLK_OUT1)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.1, C11.2, C12.2, D1.3 (VSS), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J2.4 (GND), J3.1, J3.7, J3.13, J3.14, J3.18, JP1.1 (A), Q2.2 (S), R2.2, R4.2, R5.2, R13.2, U1.1 (GND), U2.1 (GND), U2.40 (GND), U2.41 (GND), U3.5 (RES), U3.6 (GND), U3.7 (GND), U3.8 (GND), U4.2 (GND), U5.3 (GND), U6.2 (VSS), U7.2 (VSS), U8.2 (GND)
unnamed: D1.4 (DIN), Q1.3 (C), R11.1
unnamed: J1.A5 (CC1), R4.1
unnamed: J1.B5 (CC2), R5.1
unnamed: J1.S1 (SHIELD), R2.1
unnamed: J2.3 (ESPTXD), R8.2
unnamed: J2.5 (ESPRXD), R9.1
unnamed: JP1.2 (B), R1.1, U3.3 (SDO/SAO)
unnamed: Q1.1 (B), R10.1
unnamed: Q2.1 (G), R12.2, R13.1
unnamed: TP2.1, U1.6 (SPK2)
unnamed: TP3.1, U1.5 (SPK1)
VBUS: C5.1, D2.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U1.8 (VCC), U4.5 (VBUS)

Notes on the sheet:
加速度计

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
Board: 2 copper layers, 44.0 x 35.8 mm, 44 parts (28 on the bottom side), 37 nets.

## Commit log

2022-09-28 Init the pcb repo
